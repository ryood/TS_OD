# Repository ryood/TS_OD

## EAGLE design eagle/TS_OD/TS_OD1.brd

Parts:
C1, C2, C4, C7, C8: 1uF; C050-050X075
C3: 68pF; C050-024X044
C5, C6: 0.22uF; C050-035X075
C9: 10uF; E2,5-5
C10: 100uF; E5-6
C11: 47uF; E5-6
D1, D2, D3: 1N4148DO35-7; DO35-7
D4: 5.1V; ZDIO-7.5
IC1: LM4558N; DIL08
JP1: IN; 1X02
JP2: DRIVE; 1X02
JP3: Tone; 1X03
JP4: Vol.; 1X03
JP5: OUT; 1X02
JP6: DCIN; 1X02
JP7: LED; 1X02
JP8: GND; 1X02
JP9: VGND; 1X02
R1: 100k; 0207/7
R2, R5, R6, R9, R14, R15, R16, R17: 10k; 0207/7
R3, R11, R12, R19: 1k; 0207/7
R4: 680; 0207/7
R7: 1k; 0207/10
R8: 4.7k; 0207/7
R10: 220; 0207/7
R13: 680k; 0207/7
R18: 100; 0207/7
T1, T2: 2SC1815; TO92-ECB

Connections:
GND: C5.2, C10.-, C11.-, IC1.4 (V-), JP1.2, JP5.2, JP6.2, JP7.2, JP8.1, JP8.2, R2.1, R5.1, R10.1, R14.1, R15.1, R17.1
unnamed: JP1.1, R1.1
unnamed: C1.1, R1.2, R2.2
unnamed: C1.2, R3.2
unnamed: C5.1, IC1.5 (+IN), JP3.2, R7.1, R9.2
unnamed: R3.1, R4.2, T1.B
unnamed: C2.1, R5.2, T1.E
unnamed: C2.2, IC1.3 (+IN), R6.2
unnamed: C3.1, C4.2, D1.A, D2.C, IC1.2 (-IN), JP2.2
unnamed: D2.A, D3.C
unnamed: C3.2, D1.C, D3.A, IC1.1 (OUT), JP2.1, R7.2
unnamed: C4.1, R8.1
unnamed: IC1.6 (-IN), JP3.3, R11.2
unnamed: C6.2, R10.2
unnamed: C6.1, JP3.1
unnamed: C7.1, IC1.7 (OUT), R11.1
unnamed: C7.2, R12.2
unnamed: JP4.1, R12.1
unnamed: C8.1, JP4.2
unnamed: C8.2, R13.2, T2.B
unnamed: R14.2, R18.2, T2.E
unnamed: C9.-, JP5.1, R15.2
unnamed: C9.+, R18.1
unnamed: D4.A, R19.2
unnamed: JP7.1, R19.1
VCC: C10.+, D4.C, IC1.8 (V+), JP6.1, R16.2, T1.C, T2.C
VCC/2: C11.+, JP4.3, JP9.1, JP9.2, R4.1, R6.1, R8.2, R9.1, R13.1, R16.1, R17.2

Notes on the sheet:
500k/B
Socket
10k/B
100k/B
R1, R8, C4, D3はピン・ソケットで実装
IC1
POT Terminal NO. 2, 1, 3

Board: 2 copper layers, 93.7 x 71.1 mm, 46 parts (0 on the bottom side), 27 nets.

## Commit log

2017-05-15 change eagle files' name from TS_OD to TS_OD1
2017-07-03 Update: eagle files Add: drawing of the case
